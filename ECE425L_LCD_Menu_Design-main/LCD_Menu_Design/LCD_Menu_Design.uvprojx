# Keil uVision project LCD_Menu_Design.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD_Menu_Design
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: GPIO.c SysTick_Delay.c Buzzer.c Timer_0A_Interrupt.c Seven_Segment_Display.c EduBase_Button_Interrupt.c PMOD_BTN_Interrupt.c PWM_Clock.c PWM0_0.c PWM1_3.c Stepper_Motor.c EduBase_LCD.c PMOD_ENC.c
  group inc
    ./: GPIO.h SysTick_Delay.h Buzzer.h Timer_0A_Interrupt.h Seven_Segment_Display.h EduBase_Button_Interrupt.h PMOD_BTN_Interrupt.h PWM_Clock.h PWM0_0.h PWM1_3.h Stepper_Motor.h EduBase_LCD.h PMOD_ENC.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
